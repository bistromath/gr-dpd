options:
  parameters:
    author: Alekh Gupta
    generate_options: qt_gui
    id: Check
    output_language: python
    title: Non-linear_Two_Tone_Setup
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tone_param_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Tone_Spacing/Freq.
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '500000'
    value: '100000'
  states: {}
- name: tone_param_1
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.2'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.00075'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: tone_param_1
    freq: tone_param_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: tone_param_1
    freq: '-tone_param_0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dpd_GMP_model_0
  id: dpd_GMP_model
  parameters:
    K_a: '5'
    K_b: '0'
    K_c: '0'
    L_a: '1'
    L_b: '0'
    L_c: '0'
    M_b: '0'
    M_c: '0'
    coeffs: (1, 0.1, 0.1)
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    K_a: '5'
    K_b: '0'
    L_a: '1'
    L_b: '0'
    M_b: '0'
    coeff1: (1, 0.1, 0.1)
    coeff2: (1)
    mode: Both
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: '[1,1,4,1]'
    name: '"Output Signal"'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: '[1,0,4,1]'
    name: '"Input Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', dpd_GMP_model_0, '0']
- [blocks_throttle_0, '0', dpd_GMP_model_PA_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_1, '0']
- [dpd_GMP_model_0, '0', qtgui_freq_sink_x_0, '0']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
