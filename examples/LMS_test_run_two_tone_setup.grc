options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: K_a
  id: variable
  parameters:
    value: '9'
  states: {}
- name: K_b
  id: variable
  parameters:
    value: '0'
  states: {}
- name: K_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: L_a
  id: variable
  parameters:
    value: '1'
  states: {}
- name: L_b
  id: variable
  parameters:
    value: '0'
  states: {}
- name: L_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: M_b
  id: variable
  parameters:
    value: '0'
  states: {}
- name: M_c
  id: variable
  parameters:
    value: '0'
  states: {}
- name: PA_coeffs
  id: variable
  parameters:
    value: np.array([coeff[0]+1j*coeff[1] for coeff in PA_coeffs_tuple])
  states: {}
- name: PA_coeffs_tuple
  id: variable
  parameters:
    value: '[(2.53372,0.0719986), (-59.7945,-2.20241), (840.837,19.0427), (-4803.29,20.5427), (7018.21,-523.916), (2162.72,-157.051), (393.877,-29.4618)]'
  states: {}
- name: amp_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Amp + feedback path gain (dB)
    orient: Qt.Horizontal
    start: '-100'
    step: '0.1'
    stop: '20'
    value: '-40'
  states: {}
- name: ampl
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.15'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '500000'
    value: '9000'
  states: {state: disabled}
- name: init_coeffs
  id: variable
  parameters:
    value: np.insert(np.array([coeff[0]+1j*coeff[1] for coeff in init_coeffs_tuple]),[1,2,3,4,5],0)
  states: {}
- name: init_coeffs_tuple
  id: variable
  parameters:
    value: '[(2.40741,0.0683709), (-51.9816,-2.19854), (662.873,23.812), (-3062.35,-72.4208), (996.622,-40.7794)]'
  states: {}
- name: lamb
  id: variable
  parameters:
    value: '1e-10'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '390625'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '7500.'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: ampl/1000
    comment: |-
      Adding a small amount
      of noise to the input helps
      regularize overdetermined systems.
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: ampl/2
    freq: 5e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: ampl/2
    freq: '-6.001e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: |-
      Compensate for magnitude
      change across amplifier +
      feedback stages
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: ampl/4
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    comment: Simulates gain/loss in the amp and feedback stages
    const: 10**(amp_gain/20.)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: Error signal
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: int(samp_rate/symbol_rate)
  states: {}
- name: dpd_GMP_model_0
  id: dpd_GMP_model
  parameters:
    K_a: K_a
    K_b: K_b
    K_c: K_c
    L_a: L_a
    L_b: L_b
    L_c: L_c
    M_b: M_b
    M_c: M_c
    alias: predistorter
    coeffs: (1)
    comment: Predistorter
  states: {}
- name: dpd_GMP_model_0_1
  id: dpd_GMP_model
  parameters:
    K_a: K_a
    K_b: K_b
    K_c: K_c
    L_a: L_a
    L_b: L_b
    L_c: L_c
    M_b: M_b
    M_c: M_c
    alias: postdistorter
    coeffs: (1)
    comment: Postdistorter
  states: {}
- name: dpd_ILA_LMS_estimator_0
  id: dpd_ILA_LMS_estimator
  parameters:
    K_a: K_a
    K_b: K_b
    K_c: K_c
    L_a: L_a
    L_b: L_b
    L_c: L_c
    M_b: M_b
    M_c: M_c
    block_size: '20000'
    coeffs: (1)
    iter_limit: '5000'
    lamb: lamb
    learning_rate: '0.4'
  states: {}
- name: dpd_lut_0
  id: dpd_lut
  parameters:
    comment: Amplifier model
    filename: /home/nick/dev/imc/skippy/gr-predistort/apps/barrett-fwd.cal
  states: {}
- name: dpd_lut_0_0
  id: dpd_lut
  parameters:
    comment: |-
      Duplicate amp model
      For showing response w/o DPD
    filename: /home/nick/dev/imc/skippy/gr-predistort/apps/barrett-fwd.cal
  states: {}
- name: guiextra_msg_push_button_0
  id: guiextra_msg_push_button
  parameters:
    label: Trigger learning
    msgName: pressed
    relBackgroundColor: default
    relFontColor: default
    type: int
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_2
  id: note
  parameters:
    note: Visualization
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"green"'
    color3: '"blue"'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: '[1,1,4,1]'
    label1: Simulated without DPD
    label2: Raw PA input
    label3: Amplifier output with DPD
    nconnections: '3'
    type: complex
    wintype: firdes.WIN_FLATTOP
    ymax: '-40'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    color3: blue
    ctrlpanel: 'True'
    gui_hint: '[1,0,4,1]'
    label1: Without DPD
    label2: PA input
    label3: With DPD
    label4: Original input
    nconnections: '4'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '0.20'
    ymin: '-0.05'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: '[1,1,4,1]'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: normalized
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: pa_in
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: pa_out
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: error
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: normalized
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: pa_in
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: pa_in
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: pa_out
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: error
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_1, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_0_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_divide_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_xx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_xx_0, '0', dpd_GMP_model_0_1, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_rms_xx_0_0, '0', blocks_divide_xx_0, '0']
- [blocks_skiphead_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_sub_xx_0, '0', dpd_ILA_LMS_estimator_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_4, '0']
- [blocks_throttle_0, '0', dpd_GMP_model_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [digital_constellation_modulator_0, '0', blocks_skiphead_0, '0']
- [dpd_GMP_model_0, '0', blocks_sub_xx_0, '0']
- [dpd_GMP_model_0, '0', dpd_ILA_LMS_estimator_0, '1']
- [dpd_GMP_model_0, '0', dpd_lut_0, '0']
- [dpd_GMP_model_0, '0', virtual_sink_2, '0']
- [dpd_GMP_model_0_1, '0', blocks_sub_xx_0, '1']
- [dpd_ILA_LMS_estimator_0, taps, blocks_message_debug_0, print]
- [dpd_ILA_LMS_estimator_0, taps, dpd_GMP_model_0, taps]
- [dpd_ILA_LMS_estimator_0, taps, dpd_GMP_model_0_1, taps]
- [dpd_lut_0, '0', blocks_multiply_const_xx_1, '0']
- [dpd_lut_0, '0', virtual_sink_3, '0']
- [dpd_lut_0_0, '0', blocks_complex_to_mag_0, '0']
- [dpd_lut_0_0, '0', qtgui_freq_sink_x_2, '0']
- [guiextra_msg_push_button_0, pressed, dpd_ILA_LMS_estimator_0, trigger]
- [virtual_source_0, '0', blocks_complex_to_mag_0_0_0, '0']
- [virtual_source_1, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [virtual_source_1_0, '0', dpd_lut_0_0, '0']
- [virtual_source_2, '0', blocks_complex_to_mag_0_0, '0']
- [virtual_source_2_0, '0', qtgui_freq_sink_x_2, '1']
- [virtual_source_3, '0', qtgui_freq_sink_x_2, '2']
- [virtual_source_4, '0', blocks_rms_xx_0_0, '0']
- [virtual_source_5, '0', blocks_complex_to_mag_1, '0']

metadata:
  file_format: 1
