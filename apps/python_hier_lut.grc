options:
  parameters:
    author: nick
    category: '[Predistort]'
    generate_options: hb
    id: dpd_hier_lut
    output_language: python
    title: DPD Python LUT
  states: {}

blocks:
- name: analog_phase_modulator_fc_0
  id: analog_phase_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: max(in_table)
    lo: min(in_table)
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dpd_lookup_table_0
  id: dpd_lookup_table
  parameters:
    method: linear
    table: (in_table, i_table)
  states: {}
- name: dpd_lookup_table_0_0
  id: dpd_lookup_table
  parameters:
    method: linear
    table: (in_table, q_table)
  states: {}
- name: i_table
  id: parameter
  parameters:
    label: I table
    value: np.linspace(0,1,11)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: in_table
  id: parameter
  parameters:
    label: Input table
    value: np.linspace(0,1,11)
  states: {}
- name: method
  id: parameter
  parameters:
    label: Method
    type: str
    value: linear
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: q_table
  id: parameter
  parameters:
    label: Q table
    value: np.linspace(0,1,11)
  states: {}

connections:
- [analog_phase_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [analog_rail_ff_0, '0', dpd_lookup_table_0, '0']
- [analog_rail_ff_0, '0', dpd_lookup_table_0_0, '0']
- [blocks_complex_to_magphase_0, '0', analog_rail_ff_0, '0']
- [blocks_complex_to_magphase_0, '1', analog_phase_modulator_fc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [dpd_lookup_table_0, '0', blocks_float_to_complex_0, '0']
- [dpd_lookup_table_0_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_0, '0', blocks_complex_to_magphase_0, '0']

metadata:
  file_format: 1
